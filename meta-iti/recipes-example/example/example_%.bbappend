python do_display_banner:append(){
    
    bb.plain("!!!!!!!!!!!!!! this is from bbappend !!!!!!!!!!!!!!")
}